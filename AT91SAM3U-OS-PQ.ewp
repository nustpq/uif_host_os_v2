# IAR project AT91SAM3U-OS-PQ.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3U4C Atmel SAM3U4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: at91sam3u4
  ICCARM.CCIncludePath2: $PROJ_DIR$; uC-CPU; uC-CPU\ARM-Cortex-M3\IAR; uC-LIB; APP; BSP; uCOS-II\Source; uC-CPU\ARM-Cortex-M3\IAR; uC-CPU; uC-LIB; uC-LIB\Ports\ARM-Cortex-M3\IAR; BSP\OS-v2; uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; uC-Probe\Target\Communication\Generic\OS\uCOS-II; uC-Probe\Target\Demos\Intro\Source; uC-Probe\Target\Plugins\uCOS-II; uC-Probe\Target\Communication\Generic\Source; uC-Probe\Target\Communication\Generic\RS-232\Ports\Atmel\AT91SAM3U; uC-Probe\Target\Communication\Generic\RS-232\Source; Noah; Driver; BSP\at91sam3u4; Shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam3u4
  OBJCOPY.OOCOutputFile: host_at91sam3u4c.bin
  ILINK.IlinkOutputFile: host_at91sam3u4c.out
  ILINK.IlinkIcfFile: e:\SVN Dir\PQ\UIF Board\host_MCU3u4c\BSP\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; uC-CPU; uC-CPU\ARM-Cortex-M3\IAR; BSP; BSP\OS-v2; Noah; Driver; Shell; uCOS-II\Source; uC-CPU; uC-LIB; uC-CPU\ARM-Cortex-M3\IAR; uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; uC-Probe\Target\Communication\Generic\OS\uCOS-II; uC-Probe\Target\Demos\Intro\Source; uC-Probe\Target\Plugins\uCOS-II; uC-Probe\Target\Communication\Generic\Source; uC-Probe\Target\Communication\Generic\RS-232\Ports\Atmel\AT91SAM3U; uC-Probe\Target\Communication\Generic\RS-232\Source; APP; BSP\at91sam3u4; uC-LIB\Ports\ARM-Cortex-M3\IAR
  OBJCOPY.OOCOutputFile: UIF2.0_Host_V.bin
  ILINK.IlinkOutputFile: AT91SAM3U-OS-PQ.out
  ILINK.IlinkIcfFile: BSP\AT91SAM3U_FLASH.icf
  group APP
    APP/: app.c app_cfg.h app_hooks.c app_probe.c app_probe.h app_vect.c cpu_cfg.h includes.h os_cfg.h probe_com_cfg.h task_cmd_parse.c task_debug_info.c task_joy.c task_noah.c task_noah_ruler.c task_shell.c task_uart_rx.c task_uart_tx.c task_uart_tx_ruler.c task_user_if.c taskcomm.h
  group BSP
    BSP/: at91sam3u4.h AT91SAM3U_FLASH.icf AT91SAM3U_FLASH.mac board.h bsp.c bsp.h bsp_cpu.c bsp_gpio.c bsp_gpio.h bsp_int.c bsp_int.h bsp_pmc.c bsp_pmc.h core_cm3.c core_cm3.h
  group BSP/OS-v2
    BSP/OS-v2/: bsp_os.c bsp_os.h
  group DRIVER
    Driver/: codec.c codec.h dma.c dma.h dmad.c dmad.h eefc.c eefc.h flashd.h flashd_eefc.c gpio.c gpio.h i2c_gpio.c i2c_gpio.h irq.h led.c led.h math.c math.h nvic.c nvic.h pio.c pio.h pio_it.c pio_it.h queue.c queue.h spi.c spi.h timer.c timer.h twi.c twi.h twid.c twid.h uart.c uart.h
  group NOAH
    Noah/: dsp.c dsp.h emb.c emb.h fm1388.c fm1388.h im501_comm.c im501_comm.h kfifo.c kfifo.h mem_basic.c mem_basic.h noah_cmd.c noah_cmd.h ruler.c ruler.h sine_table.c sine_table.h uif.c uif.h Xmodem.c Xmodem.h
  group SHELL
    Shell/: commands.c commands.h
  group uC/CPU
    uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports
    uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-II/Ports
    uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/Probe/Target/Communication/Generic/OS/uCOS-II
    uC-Probe/Target/Communication/Generic/OS/uCOS-II/: probe_com_os.c
  group uC/Probe/Target/Communication/Generic/RS-232/OS/uCOS-II
    uC-Probe/Target/Communication/Generic/RS-232/OS/uCOS-II/: probe_rs232_os.c
  group uC/Probe/Target/Communication/Generic/RS-232/Ports/Atmel/AT91SAM3U
    uC-Probe/Target/Communication/Generic/RS-232/Ports/Atmel/AT91SAM3U/: probe_rs232c.c probe_rs232c.h
  group uC/Probe/Target/Communication/Generic/RS-232/Source
    uC-Probe/Target/Communication/Generic/RS-232/Source/: probe_rs232.c probe_rs232.h
  group uC/Probe/Target/Demos/Source
    uC-Probe/Target/Demos/Intro/Source/: probe_demo_intro.c probe_demo_intro.h
  group uC/Probe/Target/Demos/Workspaces
    uC-Probe/Target/Demos/Intro/Workspaces/: Probe-Demo-Intro-Workspace.wsp
  group uC/Probe/Target/Plugins/uCOS-II
    uC-Probe/Target/Plugins/uCOS-II/: os_probe.c os_probe.h
